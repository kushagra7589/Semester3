# Keil uVision project Interrupt_handling.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Interrupt_handling
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: Interrupt.a51
